<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Driver_CEM.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Thanh ghi STM32\libraries\C&amp;C++\Embedded_C99\Microcontroller\STM32f10x\test_lib\sm32f103c8t6\test.ewp</path>
    </project>
    <batchBuild />
</workspace>

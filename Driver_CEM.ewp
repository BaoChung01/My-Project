# IAR project Driver_CEM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\HP\Documents\Driver_STM32\Driver STM32F1\Driver\Src; C:\Users\HP\Documents\Driver_STM32\Driver STM32F1\Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Driver_CEM.srec
  ILINK.IlinkOutputFile: Driver_CEM.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group Driver/Inc
    Driver/Inc/: stm32_gpio.h stm32_i2c.h stm32_rcc.h stm32_spi.h stm32_uart.h stm32f1.h
  group Driver/Src
    Driver/Src/: spi_test.c stm32_gpio.c stm32_i2c.c stm32_rcc.c stm32_spi.c stm32_uart.c

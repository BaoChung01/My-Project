# Keil uVision project Project.uvprojx, settings and files
target STM32F411xE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411xE
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F411xE, HSE_VALUE = 8000000
  c misc: --C99
  c include: ../;../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../Libraries/STM32F4xx_StdPeriph_Driver/inc;.\config;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS;.\FreeRTOS\include;..\MDK-ARM;..\..\Libraries\MP3_Module\inc;..\..\Libraries\USB_Module\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../: main.c stm32f4xx_it.c
    ./: startup_stm32f411xe.s user_interrupt.c user_function.c common.c
  group CMSIS
    ../: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ./FreeRTOS/: timers.c tasks.c queue.c list.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group LED
    ./: DelayLED.c ModuleLED.c ButtonControl.c ButtonControl.h ModuleI3G4250D.c ModuleI3G4250D.h
  group Include
    ./: user_interrupt.h user_function.h common.h
  group AudioModule
    ../../Libraries/MP3_Module/src/: Audio.c bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3.c mp3dec.c mp3tabs.c polyphase.c scalfact.c stproc.c subband.c trigtabs_fixpt.c
  group USBModule
    ../../Libraries/USB_Module/src/: ccsbcs.c fattime.c ff.c usb_bsp.c usb_core.c usb_hcd.c usb_hcd_int.c USB_Requirement.c USB_USART.c usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c usbh_stdreq.c usbh_usr.c
software components: CMSIS:CORE 5.2.0
